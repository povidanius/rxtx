<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bladerf_selection</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_rx_frequency</value></param>
<param><key>value</key><value>rx_frequency</value></param>
<param><key>gui_hint</key><value>0, 0, 1, 5</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>3.8e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_rx_sample_rate</value></param>
<param><key>value</key><value>rx_sample_rate</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 2</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.5e6</value></param>
<param><key>step</key><value>500e3</value></param>
<param><key>stop</key><value>40e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_rx_sample_rate_0</value></param>
<param><key>value</key><value>rx_sample_rate</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 2</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.5e6</value></param>
<param><key>step</key><value>500e3</value></param>
<param><key>stop</key><value>40e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>./data.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>gui_rx_frequency</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rx_sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>gui_rx_sample_rate</value></param>
<param><key>fc</key><value>gui_rx_frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2, 0, 5, 5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>7, 0, 3, 10</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>4024</value></param>
<param><key>srate</key><value>rx_sample_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>433874000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_sample_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
